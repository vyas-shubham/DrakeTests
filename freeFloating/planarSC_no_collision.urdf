Commit message: Update for new stackoverflow questions

File: freeFloating/planarSC_no_collision.urdf (robot description, URDF)
Before this commit: robot planarDetumble, 6 links, 5 joints
Links:
- link link_ee: mass None -> 0.1
